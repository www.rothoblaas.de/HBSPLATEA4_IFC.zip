Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView], RevitIdentifiers [VersionGUID: 61aeac18-1b75-487f-889b-a16492edc991, NumberOfSaves: 42], CoordinateReference [CoordinateBase: Project Base Point, ProjectSite: Planimetria di default]
File name: ROTHOB_Rothoblaas_Screw_HBSPlateA4_10140.ifc
Time: 2025-07-28T16:36:48
Written by: ODA IFC SDK 22.8
Made in: 22.1.80.32 - IFC 22.7.0.0 - Default UI

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 mm
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuildingStorey: Livello:Livello, 0_Rothoblaas
LongName: 0_Rothoblaas; Elevation: 0 mm
Vincoli - Quota altimetrica: 0 mm
Quote - Altezza di calcolo: 0 mm
Dati identità - Nome: 0_Rothoblaas; Piano edificio: yes; Strutturale: no
Altro - Categoria: Livelli; Famiglia: Livello; Famiglia e tipo: Livello: Livello; ID tipo: 927; Tipo: Livello
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello : Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Dati identità(Type) - Nome del tipo: Livello
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello

# IfcMechanicalFastener: Collegamenti strutturali : ROTHOB_Rothoblaas_Screw_HBSPlateA4 : HBSPL10140A4_10x140mm
In: 0_Rothoblaas
Type - Material: ROTHOB_Rothoblaas_StainlessSteelAISI316
Type - Generale - Author: Augusto Meorali; BIMObjectName: ROTHOB_Rothoblaas_Screw_HBSPlateA4; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23.20.40.11.14.24; OmniClassTitle: Screws; OmniClassVersion: 2012-05-16; ProductInformation: www.rothoblaas.com/products/fastening/screws/hbs-plate-a4; Revision: 000; UniClass2015Code: Pr_20_29_76_75; UniClass2015Title: Self-tapping screws; UniClass2015Version: Products v1.38; Version: 001
Type - Testo - HeadType: Reinforced pan head
Type - Vincoli - ModelNumberCode: 10140; Prospetto di default: 1219.2 mm
Type - Materiali e finiture - ObjectMaterial: ROTHOB_Rothoblaas_StainlessSteelAISI316
Type - Quote - H1: 3.5556 mm; H2: 0.835 mm; HeadDiameter_dk: 16.5 mm; HeadThickness_t1: 7.6 mm; InsertionLength_L: 140 mm; NominalDiameter_d1: 10 mm; ShankDiameter_ds: 7.2 mm; ShankLength: 22.5547 mm; ThreadDiameter_d2: 6.6 mm; ThreadLength_b: 110 mm; ThreadRadius: 3.3 mm; TipLength: 13.2356 mm; UnderheadDiameter: 12 mm; UnderheadLength: 3.4722 mm; WasherThickness_tk: 4.5 mm
Type - Dati identità - Descrizione: Pan head screws for plates; Nome del tipo: HBSPL10140A4_10x140mm; Numero OmniClass: 23.20.40.11.14.24; Produttore: info@rothoblaas.com; Titolo OmniClass: Screws
Type - Altro - Categoria: Collegamenti strutturali; AccessibilityPerformance: n/a; AssetType: Fixed; BitType: 40; Category: Pr_20_29_76_75: Self-tapping screws; CECode: ETA-11/0030; CETitle: Rotho Blaas Self-tapping screws and threaded rods; CodePerformance: CE - Construction products; Color: Silver; Constituents: n/a; Description: Pan head screws for plates; DurationUnit: Years; ExpectedLife: 50; Features: Self-tapping screws for steel-timber connections; Finish: Stainless steel; Grade: n/a; GTIN: 8059386076897; ICC-ESCode: ESR-4645; ICC-ESTitle: Rotho blaas self-tapping wood screws; Manufacturer: info@rothoblaas.com; Material: A4 | AISI316 austenitic stainless steel (CRC III); MinWeight: n/a; ModelDisclaimer: The latest version of the data sheets can be found on our website; ModelNumber: HBSPL10140A4; ModelReference: n/a; Name: Screw; Nome famiglia: ROTHOB_Rothoblaas_Screw_HBSPlateA4; NominalDiameter: 10 mm; NominalHeight: n/a; NominalLength: 140 mm; NominalWidth: n/a; ReplacementCost: n/a; Shape: Cylindrical; Size: 10x140 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Silver
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: info@rothoblaas.com
Type - Pset_ProductRequirements - Name: Screw; Category: Pr_20_29_76_75: Self-tapping screws
Pset_QuantityTakeOff - Reference: HBSPL10140A4_10x140mm
Vincoli - Host: Livello : 0_Rothoblaas; Livello: 0_Rothoblaas; Livello abaco: 0_Rothoblaas; Quota altimetrica da livello: 0 mm
Fasi - Fase di creazione: Stato di Progetto
Quote - Area: 0.00173825 m2; Volume: 0.00000601369 m3
Altro - Famiglia: ROTHOB_Rothoblaas_Screw_HBSPlateA4; Famiglia e tipo: ROTHOB_Rothoblaas_Screw_HBSPlateA4: HBSPL10140A4_10x140mm; ID tipo: 338070; Tipo: HBSPL10140A4_10x140mm
